Commit message: Update

File: arm_config_547.urdf (robot description, URDF)
Before this commit: robot arm_config_547, 9 links, 8 joints
Joints:
- joint GripperJoint: type revolute -> fixed
- joint MirrorGripperJoint: type revolute -> fixed
